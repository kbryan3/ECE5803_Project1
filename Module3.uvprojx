# Keil uVision project Module3.uvprojx, settings and files
target serial_port_debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: serial_port_debug
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: DEVICE_PORTOUT=1 TARGET_KLXX __CORTEX_M0PLUS DEVICE_SEMIHOST=1 __ASSERT_MSG TARGET_RELEASE DEVICE_SLEEP=1 DEVICE_PORTINOUT=1 MBED_BUILD_TIMESTAMP=1539029590.88 TARGET_FF_ARDUINO TARGET_M0P DEVICE_SPISLAVE=1 TARGET_KL25Z DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 TARGET_LIKE_CORTEX_M0 DEVICE_ANALOGIN=1 TARGET_CORTEX_M ARM_MATH_CM0PLUS TARGET_Freescale DEVICE_USTICKER=1 DEVICE_I2C=1 DEVICE_PORTIN=1 TOOLCHAIN_ARM DEVICE_I2CSLAVE=1 TOOLCHAIN_ARM_STD DEVICE_PWMOUT=1 TARGET_LIKE_MBED DEVICE_SPI=1 __MBED__=1 DEVICE_SERIAL=1 TARGET_CORTEX DEVICE_INTERRUPTIN=1 __CMSIS_RTOS __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti -c --split_sections --no_depend_system_headers --md --gnu --apcs=interwork --cpu=Cortex-M0 --preinclude=mbed_config.h
  c include: .;mbed;mbed/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed\TARGET_KL25Z\TOOLCHAIN_ARM_STD\MKL25Z4.sct
  link misc: --show_full_path
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o mbed_tz_context.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MKL25Z4.o system_MKL25Z4.o us_ticker.o
    mbed/TARGET_KL25Z/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mbed_cmsis_conf.h mpu_armv7.h mpu_armv8.h RTE_Components.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device/: cmsis.h cmsis_nvic.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
    mbed/: mbed.h
    mbed/TARGET_KL25Z/TARGET_Freescale/: mbed_rtx.h
  group serial_port_debug
    ./: main.cpp mbed_config.h Monitor.cpp shared.h timer0.cpp UART_poll.cpp
